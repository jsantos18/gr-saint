options:
  parameters:
    author: Julian Santos
    copyright: Julian Santos
    description: A graph to test new blocks and design
    generate_options: qt_gui
    id: test_graph
    output_language: python
    run_options: run
    title: Testing Flowgraph
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(32e3)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: saint_burst_message_multiplexer_0
  id: saint_burst_message_multiplexer
  parameters:
    burst_size: '1024'
    sample_rate: samp_rate
    worker_threads: '4'
  states: {}
- name: saint_stream_to_burst_message_0
  id: saint_stream_to_burst_message
  parameters:
    burst_size: '1024'
    freq_offset: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', saint_stream_to_burst_message_0, '0']
- [blocks_throttle_1, '0', qtgui_time_sink_x_0, '0']
- [saint_burst_message_multiplexer_0, '0', blocks_throttle_1, '0']
- [saint_stream_to_burst_message_0, out, saint_burst_message_multiplexer_0, in]

metadata:
  file_format: 1
